# Keil uVision project prj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM;..\USER;D:\Keil_v5\ARM\ARMCC\include;..\HW\IIC;..\HW\LCD;..\HW\RTC;..\HW\MAX30102;..\HW\work;..\HW\CT1711;..\HW\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group HW
    ../HW/IIC/: myiic.c
    ../HW/RTC/: rtc.c
    ../HW/MAX30102/: algorithm.c max30102.c
    ../HW/work/: work.c
    ../HW/CT1711/: CT1711.c
    ../HW/KEY/: key.c
    ../HW/LCD/: lcd.c lcd_init.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
